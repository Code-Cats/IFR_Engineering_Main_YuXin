# Keil uVision project IFR_Engineering_Main_2018.uvprojx, settings and files
target IFR_Engineering_Main_2018 (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IFR_Engineering_Main_2018 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__FPU_USED =1
  c include: ..\STM32MCU;..\ROBOT\ALGO;..\ROBOT\APP;..\ROBOT\BSP;..\ROBOT\MODULE\MPU60500;..\USER;..\ROBOT\ANALYSIS;..\ROBOT\MODULE\IMU_Uranus
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: common_definition.h main.c
  group BSP
    ../ROBOT/BSP/: bsp.c can1.c can2.c gpio.c heartbeat.c pwm.c usart1_remote.c usart3_viceboard.c usart6_wifi_Debug.c
  group APP
    ../ROBOT/APP/: chassis.c lift.c bullet_lift.c gpioctrl.c control.c protect.c auto_lift.c take_bullet.c semi_automatic_landing.c trailer.c image_control.c replenish_bullet.c uphill_auto_lift.c
  group ALGO
    ../ROBOT/ALGO/: delay.c filter.c pid.c
  group MPU6050
    ../ROBOT/MODULE/MPU60500/: mpu6050_it.c mpu6050_process.c mpu6050IIC.c
  group FWLIB
    ../STM32MCU/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_it.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c system_stm32f4xx.c startup_stm32f4xx.s
  group ANALYSIS
    ../ROBOT/ANALYSIS/: can1_analysis.c can2_analysis.c usart6_wifi_Debug_OSC.c remote_analysis.c viceboard_analysis.c
  group IMU_URANUS
    ../ROBOT/MODULE/IMU_Uranus/: dma_uart4.c imu_data_decode.c packet.c uart4.c
  group REDEME
    ../: readme.txt
